# Keil uVision project TEST2.uvprojx, settings and files
target Tartget1 (6230000::V6.23::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F103_20250407;.\lora;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./: main.c system_stm32f10x.c stm32f10x_it.c
  group lib
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_i2c.c stm32f10x_adc.c misc.c stm32f10x_exti.c stm32f10x_spi.c
    ./: delay.c timer.c dht11.c i2c.c i2c_lcd.c pwm.c adc.c adc.h rain.h rain.c water_level.h water_level.c flow_sensor.h flow_sensor.c analog.h analog.c art.h art.c dht22.h dht22.c motor.h motor.c
  group lora
    ./lora/: lora_radio.c lora_radio.h lora_protocol.c lora_protocol.h lora_node.c lora_node.h lora_network_config.h
  group startup
    ./: startup_stm32f10x_md.s
